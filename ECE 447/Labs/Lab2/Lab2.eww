<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


